# Keil uVision project FreeRTOS_STemWin.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: FreeRTOS_STemWin
  c flags: OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\Libraries\STM32F10x_FWLib\inc;..\Drive;..\Drive\usart;..\Drive\led;..\Drive\lcd;..\System\sys;..\System\delay;..\Libraries\CMSIS\Device\ST\STM32F10x\Include;..\Libraries\CMSIS\Include;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3;..\emWin\Config;..\emWin\DisplayDriver;..\emWin\emWinTask;..\emWin\Include;..\Drive\SRAM;..\Drive\TOUCH;..\Drive\24CXX;..\Drive\IIC
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Core
    ../Libraries/CMSIS/Device/ST/STM32F10x/Source/Templates/: system_stm32f10x.c
  group StarUp
    ../Libraries/CMSIS/Device/ST/STM32F10x/Source/Templates/arm/: startup_stm32f10x_hd.s
  group STM32_LIB
    ../Libraries/STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_crc.c stm32f10x_fsmc.c
  group FreeRTOS/Source
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/Ports
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ../FreeRTOS/portable/MemMang/: heap_1.c
  group User
    ./: main.c
  group System
    ../System/sys/: sys.c
    ../System/delay/: delay.c
  group Drive
    ../Drive/: bsp_init.c
    ../Drive/usart/: bsp_usart.c
    ../Drive/led/: bsp_led.c
    ../Drive/SRAM/: SRAM.c
    ../Drive/IIC/: myiic.c
    ../Drive/24CXX/: 24cxx.c
  group LCD_Driver
    ../emWin/DisplayDriver/: GUIDRV_Template.c
    ../Drive/TOUCH/: touch.c
    ../Drive/lcd/: lcd.c
  group GUI_X
    ../emWin/GUI_X/: GUI_X_FreeRTOS.c GUI_X_Touch_Analog.c
  group GUI/Config
    ../emWin/Config/: GUIConf.c GUIConf.h LCDConf.c LCDConf.h
  group GUI/DEMO
    ../emWin/emWinTask/: MainTask.c MainTask.h
  group GUI/Lib
    ../emWin/GUILib/: STemWin528_CM3_OS_Keil.lib
software components: CMSIS:CORE 4.3.0
